# Keil uVision project temperature_sensor.uvprojx, settings and files
target Debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ADuCM4050 Analog Devices
  pack: AnalogDevices.ADuCM4x50_DFP.1.0.0
  cpu: IRAM(0x20000000,0x04000) IRAM2(0x20040000,0x14000) IROM(0x00000000,0x7F000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: temperature_sensor
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x14000
  group src
    ../: adi_pinmux.c Readme_temperature_sensor.txt
    ../../: temperature_sensor.c
target Release (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ADuCM4050 Analog Devices
  pack: AnalogDevices.ADuCM4x50_DFP.1.0.0
  cpu: as above
  output: temperature_sensor
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x14000
software components: CMSIS:CORE 5.0.0, Device:Drivers:DMA 1.0.0, Device:Drivers:I2C 1.0.0, Device:Drivers:Power 1.0.0, Device:Drivers:UART 1.0.0, Device:Drivers:WDT 1.0.0, Device:Examples Support 1.0.0, Device:Global Configuration 1.0.0, Device:Retarget_UART 1.0.0, Device:Startup 1.0.0, Compiler:I/O:STDERR 1.1.0, Compiler:I/O:STDIN 1.1.0, Compiler:I/O:STDOUT 1.1.0, Compiler:I/O:TTY 1.1.0
