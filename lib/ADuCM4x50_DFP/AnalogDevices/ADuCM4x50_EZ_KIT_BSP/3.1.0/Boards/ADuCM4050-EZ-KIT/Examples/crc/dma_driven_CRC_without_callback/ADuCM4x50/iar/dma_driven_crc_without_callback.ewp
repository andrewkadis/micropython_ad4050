# IAR project dma_driven_crc_without_callback.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\Include\config; ..\..\..\..\..\Include; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: ADuCM4050-flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ..\..\config; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  group (top)
    ../: Readme_dma_driven_crc_without_callback.txt
  group Source
    ../../: dma_driven_crc_without_callback.c dma_driven_crc_without_callback.h
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.0}$/CMSIS/Documentation/Core/html/: index.html
  group CMSIS-Pack/Device Drivers
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/crc/: adi_crc.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/crc/: adi_crc.h
    RTE/ADuCM4x50_DFP/AnalogDevices/: adi_crc_config.h adi_global_config.h adi_pwr_config.h adi_wdt_config.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/dma/: adi_dma.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/dma/: adi_dma.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/pwr/: adi_pwr.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/pwr/: adi_pwr.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/wdt/: adi_wdt.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/wdt/: adi_wdt.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Documents/html/: group___c_r_c___driver.html group___d_m_a___driver.html group___power___driver.html group___w_d_t___driver.html
  group CMSIS-Pack/Device Examples Support
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/: common.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/: common.h
  group CMSIS-Pack/Device Global Configuration
    RTE/ADuCM4x50_DFP/AnalogDevices/: adi_cycle_counting_config.h
  group CMSIS-Pack/Device Startup
    RTE/ADuCM4x50_DFP/AnalogDevices/: startup_ADuCM4050.s system_ADuCM4050.c system_ADuCM4050.h
