# IAR project freertos_spi_loopback.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\inc\config; ..\..\..\..\..\Include\; ..\..\..\..\..\Include\rtos_map; ..\..\..\..\..\Include\config; $_ADI_FREERTOS_PATH_$\include; $_ADI_FREERTOS_PATH_$\portable\IAR\ARM_CM4F; $_ADI_FREERTOS_PATH_PLUS_$\Include; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: ..\..\inc; ..\..\inc\config; ..\..\..\..\..\Include\; ..\..\..\..\..\Include\rtos_map; ..\..\..\..\..\Include\config; $_ADI_FREERTOS_PATH_$\include; $_ADI_FREERTOS_PATH_$\portable\IAR\ARM_CM4F; $_ADI_FREERTOS_PATH_PLUS_$\Include; $_ADI_FREERTOS_PATH_PLUS_$\Config; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: freertos_test.srec
  ILINK.IlinkOutputFile: freertos_spi_loopback.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: ADuCM4050-flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ..\..\inc; ..\..\inc\config; ..\..\..\..\..\Include\; ..\..\..\..\..\Include\rtos_map; ..\..\..\..\..\Include\config; $_ADI_FREERTOS_PATH_$\include; $_ADI_FREERTOS_PATH_$\portable\IAR\ARM_CM4F; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  group (top)
    ../../: Readme_freertos_spi_loopback.txt
  group FreeRTOS
    ../../../../../../../../../../FreeRTOS/FreeRTOSv9.0.0/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/config
    ../../inc/: FreeRTOSConfig.h
  group FreeRTOS/include
    ../../../../../../../../../../FreeRTOS/FreeRTOSv9.0.0/FreeRTOS/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS/portable/IAR/ARM_CM4F
    ../../../../../../../../../../FreeRTOS/FreeRTOSv9.0.0/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group FreeRTOS+Trace
    ../../../../../../../../../../FreeRTOS/FreeRTOSv9.0.0/FreeRTOS-Plus/Source/FreeRTOS-Plus-Trace/: trcBase.c trcHardwarePort.c trcKernel.c trcKernelPort.c trcUser.c
  group FreeRTOS+Trace/Include
    ../../../../../../../../../../FreeRTOS/FreeRTOSv9.0.0/FreeRTOS-Plus/Source/FreeRTOS-Plus-Trace/Include/: trcBase.h trcHardwarePort.h trcKernel.h trcKernelHooks.h trcKernelPort.h trcTypes.h trcUser.h
  group Source
    ../../: PinMux.c spi_loopback_freertos.c spi_master_task.c spi_slave_task.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.0}$/CMSIS/Documentation/Core/html/: index.html
  group CMSIS-Pack/Device Drivers
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/dma/: adi_dma.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/dma/: adi_dma.h
    RTE/ADuCM4x50_DFP/AnalogDevices/: adi_global_config.h adi_pwr_config.h adi_spi_config.h adi_wdt_config.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/gpio/: adi_gpio.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/gpio/: adi_gpio.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/pwr/: adi_pwr.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/pwr/: adi_pwr.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/spi/: adi_spi.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/spi/: adi_spi.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/wdt/: adi_wdt.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/wdt/: adi_wdt.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Documents/html/: group___d_m_a___driver.html group___g_p_i_o___driver.html group___power___driver.html group___s_p_i___driver.html group___w_d_t___driver.html
  group CMSIS-Pack/Device Examples Support
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/: common.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/: common.h
  group CMSIS-Pack/Device Global Configuration
    RTE/ADuCM4x50_DFP/AnalogDevices/: adi_cycle_counting_config.h
  group CMSIS-Pack/Device Startup
    RTE/ADuCM4x50_DFP/AnalogDevices/: startup_ADuCM4050.s system_ADuCM4050.c system_ADuCM4050.h
