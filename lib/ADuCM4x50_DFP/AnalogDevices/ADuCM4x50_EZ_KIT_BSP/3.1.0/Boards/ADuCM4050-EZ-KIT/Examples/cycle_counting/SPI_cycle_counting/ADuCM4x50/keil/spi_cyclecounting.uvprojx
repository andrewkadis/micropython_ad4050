# Keil uVision project spi_cyclecounting.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ADuCM4050 Analog Devices
  pack: AnalogDevices.ADuCM4x50_DFP.3.1.0
  cpu: IRAM(0x20000000,0x04000) IRAM2(0x20040000,0x14000) IROM(0x00000000,0x7F000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: spi_cyclecounting
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ADI_DEBUG
  memory RVCT4: ROM 0x0 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x14000
  group Source
    ../../: spi_cyclecounting.c
    ../: Readme_spi_cyclecounting.txt PinMux.c
target Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ADuCM4050 Analog Devices
  pack: AnalogDevices.ADuCM4x50_DFP.3.1.0
  cpu: as above
  output: spi_cyclecounting
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x14000
software components: CMSIS:CORE 5.0.2, Device:Cycle Count 3.1.0, Device:Drivers:DMA 3.1.0, Device:Drivers:GPIO 3.1.0, Device:Drivers:Power 3.1.0, Device:Drivers:SPI 3.1.0, Device:Drivers:UART 3.1.0, Device:Drivers:WDT 3.1.0, Device:Examples Support 3.1.0, Device:Global Configuration 3.1.0, Device:Retarget_UART 3.1.0, Device:Startup 3.1.0, Compiler:I/O:STDERR 1.1.0, Compiler:I/O:STDIN 1.1.0, Compiler:I/O:STDOUT 1.1.0, Compiler:I/O:TTY 1.1.0
