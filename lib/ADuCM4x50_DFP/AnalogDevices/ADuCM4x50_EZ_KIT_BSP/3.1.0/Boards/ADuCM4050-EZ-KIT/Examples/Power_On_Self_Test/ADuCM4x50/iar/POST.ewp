# IAR project POST.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG; POST_COMMON_USES_UART; __ADUCM4050__; EZKIT_REV_1_0; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: POST_COMMON_USES_UART; EZKIT_REV_1_0; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: POST.bin
  ILINK.IlinkOutputFile: POST.out
  ILINK.IlinkIcfFile: ADuCM4050-flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; POST_COMMON_USES_UART; __ADUCM4050__; EZKIT_REV_1_0; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: POST.srec
  group (top)
    ../: adc_test.c adxl363_test.c beep_test.c flash_page_write.h lfx_test.c main.c pbled_test.c pbled_test.h post_common.c post_common.h post_pinmux.c processor_version_test.c Readme_post.txt rgb_pinmux.c rgb_tmr_test.c rtc_test.c spi_flash_test.c timer_isr.c timer_isr.h twi_temp_test.c uart_test.c wakeup_button.h wakeup_test.c
    ../../../tmr/tmr_example_gp/: tmr_example_gp.h
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Board Support ADXL363
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_EZ_KIT_BSP#3.0.0}$/Source/drivers/adxl363/: adi_adxl363.c
    RTE/ADuCM4x50_EZ_KIT_BSP/AnalogDevices/: adi_adxl363_config.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_EZ_KIT_BSP#3.0.0}$/Documents/html/: group___a_d_x_l363___driver.html
  group CMSIS-Pack/Board Support SPI Flash
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_EZ_KIT_BSP#3.0.0}$/Source/drivers/spi-flash/w25q32/: adi_w25q32.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_EZ_KIT_BSP#3.0.0}$/Documents/html/: group___w25_q32___driver.html
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.0}$/CMSIS/Documentation/Core/html/: index.html
  group CMSIS-Pack/Device Drivers
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/adc/: adi_adc.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/adc/: adi_adc.h
    RTE/ADuCM4x50_DFP/AnalogDevices/: adi_adc_config.h adi_beep_config.h adi_flash_config.h adi_global_config.h adi_i2c_config.h adi_pwr_config.h adi_rtc_config.h adi_spi_config.h adi_tmr_config.h adi_uart_config.h adi_wdt_config.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/beep/: adi_beep.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/beep/: adi_beep.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/dma/: adi_dma.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/dma/: adi_dma.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/flash/: adi_flash.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/flash/: adi_flash.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/gpio/: adi_gpio.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/gpio/: adi_gpio.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/i2c/: adi_i2c.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/i2c/: adi_i2c.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/pwr/: adi_pwr.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/pwr/: adi_pwr.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/rtc/: adi_rtc.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/rtc/: adi_rtc.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/spi/: adi_spi.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/spi/: adi_spi.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/tmr/: adi_tmr.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/tmr/: adi_tmr.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/uart/: adi_uart.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/uart/: adi_uart.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/wdt/: adi_wdt.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/wdt/: adi_wdt.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/xint/: adi_xint.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/xint/: adi_xint.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Documents/html/: group___a_d_c___driver.html group___b_e_e_p___driver.html group___d_m_a___driver.html group___flash___driver.html group___g_p_i_o___driver.html group___i2_c___driver.html group___power___driver.html group___r_t_c___driver.html group___s_p_i___driver.html group___t_m_r___driver.html group___u_a_r_t___driver.html group___w_d_t___driver.html group___x_i_n_t___driver.html
  group CMSIS-Pack/Device Global Configuration
    RTE/ADuCM4x50_DFP/AnalogDevices/: adi_cycle_counting_config.h
  group CMSIS-Pack/Device Startup
    RTE/ADuCM4x50_DFP/AnalogDevices/: startup_ADuCM4050.s system_ADuCM4050.c system_ADuCM4050.h
