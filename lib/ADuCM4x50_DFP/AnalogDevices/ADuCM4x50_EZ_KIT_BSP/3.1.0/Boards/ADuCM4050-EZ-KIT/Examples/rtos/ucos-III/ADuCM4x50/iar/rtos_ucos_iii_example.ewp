# IAR project rtos_ucos_iii_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\Include\config; ..\..\..\..\..\Include; $_ADUCM4x50_MICRIUM_DIR_$\uC-CPU\ARM-Cortex-M4\IAR; $_ADUCM4x50_MICRIUM_DIR_$\uC-CPU\; $_ADUCM4x50_MICRIUM_DIR_$\uC-LIB\; $_ADUCM4x50_MICRIUM_DIR_$\; $_ADUCM4x50_MICRIUM_DIR_$\uCOS-III\Source; $_ADUCM4x50_MICRIUM_DIR_$\uCOS-III; $_ADUCM4x50_MICRIUM_DIR_$\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\IAR; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: temperature_sensor.srec
  ILINK.IlinkOutputFile: rtos_ucos_iii_example.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: ADuCM4050-flash.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\Include\config; ..\..\..\..\..\Include; $_ADUCM4x50_MICRIUM_DIR_$\uC-CPU\ARM-Cortex-M4\IAR; $_ADUCM4x50_MICRIUM_DIR_$\uC-CPU\; $_ADUCM4x50_MICRIUM_DIR_$\uC-LIB\; $_ADUCM4x50_MICRIUM_DIR_$\; $_ADUCM4x50_MICRIUM_DIR_$\uCOS-III\Source; $_ADUCM4x50_MICRIUM_DIR_$\uCOS-III; $_ADUCM4x50_MICRIUM_DIR_$\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rtos_ucos_iii_example.srec
  group (top)
    ../: Readme_ucos_iii_example.txt
  group Micrium/uC-CPU
    $_ADUCM4x50_MICRIUM_DIR_$/uC-CPU/: cpu_core.c
  group Micrium/uC-CPU/IAR
    $_ADUCM4x50_MICRIUM_DIR_$/uC-CPU/ARM-Cortex-M4/IAR/: cpu_a.asm cpu_c.c
  group Micrium/uC-Lib
    $_ADUCM4x50_MICRIUM_DIR_$/uC-LIB/: lib_mem.c lib_str.c
  group Micrium/uCOS-III/Ports
    $_ADUCM4x50_MICRIUM_DIR_$/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group Micrium/uCOS-III/Source
    $_ADUCM4x50_MICRIUM_DIR_$/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group Micrium/uCOS-III/TLS
    $_ADUCM4x50_MICRIUM_DIR_$/uCOS-III/TLS/IAR/: os_tls.c
  group Source
    ../../: os_app_hooks.c rtos_ucos_iii_example.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.0}$/CMSIS/Documentation/Core/html/: index.html
  group CMSIS-Pack/Device Drivers
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/crypto/: adi_crypto.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/crypto/: adi_crypto.h
    RTE/ADuCM4x50_DFP/AnalogDevices/: adi_crypto_config.h adi_global_config.h adi_pwr_config.h adi_wdt_config.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/dma/: adi_dma.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/dma/: adi_dma.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/gpio/: adi_gpio.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/gpio/: adi_gpio.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/pwr/: adi_pwr.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/pwr/: adi_pwr.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/wdt/: adi_wdt.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/wdt/: adi_wdt.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Documents/html/: group___crypto___driver.html group___d_m_a___driver.html group___g_p_i_o___driver.html group___power___driver.html group___w_d_t___driver.html
  group CMSIS-Pack/Device Examples Support
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/: common.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/: common.h
  group CMSIS-Pack/Device Global Configuration
    RTE/ADuCM4x50_DFP/AnalogDevices/: adi_cycle_counting_config.h
  group CMSIS-Pack/Device Startup
    RTE/ADuCM4x50_DFP/AnalogDevices/: startup_ADuCM4050.s system_ADuCM4050.c system_ADuCM4050.h
