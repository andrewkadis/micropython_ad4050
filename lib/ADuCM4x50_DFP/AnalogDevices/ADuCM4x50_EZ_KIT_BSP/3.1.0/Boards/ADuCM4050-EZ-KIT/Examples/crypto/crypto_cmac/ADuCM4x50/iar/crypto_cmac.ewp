# IAR project crypto_cmac.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: crypto_cmac.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: ADuCM4050-flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: Readme_crypto_cmac.txt
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.1}$/CMSIS/Documentation/Core/html/: index.html
  group CMSIS-Pack/Device Drivers
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/crypto/: adi_crypto.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/crypto/: adi_crypto.h
    RTE/ADuCM4x50_DFP/AnalogDevices/: adi_crypto_config.h adi_global_config.h adi_pwr_config.h adi_uart_config.h adi_wdt_config.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/dma/: adi_dma.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/dma/: adi_dma.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/pwr/: adi_pwr.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/pwr/: adi_pwr.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/uart/: adi_uart.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/uart/: adi_uart.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/wdt/: adi_wdt.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/wdt/: adi_wdt.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Documents/html/: group___crypto___driver.html group___d_m_a___driver.html group___power___driver.html group___u_a_r_t___driver.html group___w_d_t___driver.html
  group CMSIS-Pack/Device Examples Support
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/: common.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/: common.h
  group CMSIS-Pack/Device Global Configuration
    RTE/ADuCM4x50_DFP/AnalogDevices/: adi_cycle_counting_config.h
  group CMSIS-Pack/Device Startup
    RTE/ADuCM4x50_DFP/AnalogDevices/: startup_ADuCM4050.s system_ADuCM4050.c system_ADuCM4050.h
  group Source
    ../../: crypto_cmac.c crypto_cmac.h
