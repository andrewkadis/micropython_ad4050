# Keil uVision project freertos_spi_loopback.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ADuCM4050 Analog Devices
  pack: AnalogDevices.ADuCM4x50_DFP.1.0.0
  cpu: IRAM(0x20000000,0x04000) IRAM2(0x20040000,0x14000) IROM(0x00000000,0x7F000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_spi_loopback
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\inc;..\..\inc\config;C:\FreeRTOS\FreeRTOSv9.0.0\FreeRTOS\Source\include;C:\FreeRTOS\FreeRTOSv9.0.0\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  asm include: ..\..\inc;..\..\inc\config
  memory RVCT4: ROM 0x0 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x14000
  group src
    ../../: PinMux.c spi_loopback_freertos.c spi_master_task.c spi_slave_task.c Readme_freertos_spi_loopback.txt
  group FreeRTOS
    C:/FreeRTOS/FreeRTOSv9.0.0/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    C:/FreeRTOS/FreeRTOSv9.0.0/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
target Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ADuCM4050 Analog Devices
  pack: AnalogDevices.ADuCM4x50_DFP.1.0.0
  cpu: as above
  output: freertos_spi_loopback
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: as above
  asm include: ..\..\inc;..\..\inc\config
  memory RVCT4: ROM 0x0 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x14000
software components: CMSIS:CORE 5.0.0, Device:Drivers:DMA 1.0.0, Device:Drivers:GPIO 1.0.0, Device:Drivers:Power 1.0.0, Device:Drivers:SPI 1.0.0, Device:Drivers:UART 1.0.0, Device:Drivers:WDT 1.0.0, Device:Examples Support 1.0.0, Device:Global Configuration 1.0.0, Device:Retarget_UART 1.0.0, Device:Startup 1.0.0, Compiler:I/O:STDERR 1.1.0, Compiler:I/O:STDIN 1.1.0, Compiler:I/O:STDOUT 1.1.0, Compiler:I/O:TTY 1.1.0
