# Keil uVision project POST.uvprojx, settings and files
target Debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ADuCM4050 Analog Devices
  pack: AnalogDevices.ADuCM4x50_DFP.1.0.0
  cpu: IRAM(0x20000000,0x04000) IRAM2(0x20040000,0x14000) IROM(0x00000000,0x7F000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: POST
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ADI_DEBUG
  c include: ../config
  memory RVCT4: ROM 0x0 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x14000
  group src
    ../: adxl363_test.c beep_test.c lfx_test.c main.c pbled_test.c post_common.c post_pinmux.c processor_version_test.c rgb_pinmux.c rgb_tmr_test.c rtc_test.c spi_flash_test.c timer_isr.c twi_temp_test.c uart_test.c wakeup_test.c flash_page_write.h pbled_test.h post_common.h Readme_post.txt timer_isr.h tmr_example_rgb.h wakeup_button.h adc_test.c
target Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ADuCM4050 Analog Devices
  pack: AnalogDevices.ADuCM4x50_DFP.1.0.0
  cpu: as above
  output: POST
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ADI_RELEASE
  c include: ../config
  memory RVCT4: ROM 0x0 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x14000
software components: CMSIS:CORE 5.0.0, Board Support:ADXL363 1.0.0, Board Support:SPI Flash 1.0.0, Device:Drivers:ADC 1.0.0, Device:Drivers:BEEP 1.0.0, Device:Drivers:CRC 1.0.0, Device:Drivers:Crypto 1.0.0, Device:Drivers:DMA 1.0.0, Device:Drivers:Flash 1.0.0, Device:Drivers:GPIO 1.0.0, Device:Drivers:I2C 1.0.0, Device:Drivers:Interrupt 1.0.0, Device:Drivers:Power 1.0.0, Device:Drivers:RNG 1.0.0, Device:Drivers:RTC 1.0.0, Device:Drivers:SPI 1.0.0, Device:Drivers:SPORT 1.0.0, Device:Drivers:TMR 1.0.0, Device:Drivers:UART 1.0.0, Device:Drivers:WDT 1.0.0, Device:Global Configuration 1.0.0, Device:Retarget_UART 1.0.0, Device:Startup 1.0.0, Compiler:I/O:STDERR 1.1.0, Compiler:I/O:STDIN 1.1.0, Compiler:I/O:STDOUT 1.1.0, Compiler:I/O:TTY 1.1.0
