# IAR project wakeup_button.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: temperature_sensor.srec
  ILINK.IlinkOutputFile: wakeup_button.out
  ILINK.IlinkIcfFile: ADuCM4050-flash.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: wakeup_button.srec
  group (top)
    ../: Readme_wakeup_button.txt
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.1}$/CMSIS/Documentation/Core/html/: index.html
  group CMSIS-Pack/Device Drivers
    RTE/ADuCM4x50_DFP/AnalogDevices/: adi_global_config.h adi_pwr_config.h adi_wdt_config.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/gpio/: adi_gpio.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/gpio/: adi_gpio.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/pwr/: adi_pwr.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/pwr/: adi_pwr.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/wdt/: adi_wdt.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/wdt/: adi_wdt.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/xint/: adi_xint.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/xint/: adi_xint.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Documents/html/: group___g_p_i_o___driver.html group___power___driver.html group___w_d_t___driver.html group___x_i_n_t___driver.html
  group CMSIS-Pack/Device Examples Support
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/: common.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/: common.h
  group CMSIS-Pack/Device Global Configuration
    RTE/ADuCM4x50_DFP/AnalogDevices/: adi_cycle_counting_config.h
  group CMSIS-Pack/Device Startup
    RTE/ADuCM4x50_DFP/AnalogDevices/: startup_ADuCM4050.s system_ADuCM4050.c system_ADuCM4050.h
  group Source
    ../../: wakeup_button.c
