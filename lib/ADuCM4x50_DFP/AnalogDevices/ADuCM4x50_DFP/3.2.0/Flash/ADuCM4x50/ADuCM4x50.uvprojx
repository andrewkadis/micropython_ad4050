# Keil uVision project ADuCM4x50.uvprojx, settings and files
target ADuCM4050 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ADuCM4050 Analog Devices
  pack: AnalogDevices.ADuCM4x50_DFP.3.1.0
  cpu: IRAM(0x10000000,0x08000) IRAM2(0x20000000,0x04000) IRAM3(0x20040000,0x14000) IROM(0x00000000,0x7F000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADuCM4x50
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x7f000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
