# IAR project HelloWorld.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ILINK.IlinkOutputFile: HelloWorld.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: Readme_HelloWorld.txt
  group Source
    ../../: HelloWorld.c HelloWorld.h
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.2.0}$/CMSIS/Documentation/Core/html/: index.html
  group CMSIS-Pack/Device Drivers
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Source/drivers/pwr/: adi_pwr.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Include/drivers/pwr/: adi_pwr.h
    RTE/ADuCM4x50_DFP/AnalogDevices/: adi_pwr_config.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.1.0}$/Documents/html/: group___power___driver.html
  group CMSIS-Pack/Device Global Configuration
    RTE/ADuCM4x50_DFP/AnalogDevices/: adi_cycle_counting_config.h adi_global_config.h
  group CMSIS-Pack/Device Startup
    RTE/ADuCM4x50_DFP/AnalogDevices/: startup_ADuCM4050.s system_ADuCM4050.c system_ADuCM4050.h
